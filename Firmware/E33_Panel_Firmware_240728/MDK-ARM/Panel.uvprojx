# Keil uVision project Panel.uvprojx, settings and files
target Panel (6210000::V6.21::ARMCLANG)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x240FFFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Panel +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7B0xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP;../LVGL/lvgl;../LVGL/lvgl/examples/porting;../LVGL/lvgl/src;../LVGL/lvgl/src/core;../LVGL/lvgl/src/draw;../LVGL/lvgl/src/extra;../LVGL/lvgl/src/font;../LVGL/lvgl/src/hal;../LVGL/lvgl/src/misc;../LVGL/lvgl/src/widgets;../LVGL/lvgl_app/lvgl_app_3;../App;../Drivers/BSP/ATK_MW8266D
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  scatter file: ..\Mysct\mypanel.sct
  group Application/MDK-ARM
    ./: startup_stm32h7b0xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c dma2d.c fdcan.c ltdc.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers\BSP
    ../Drivers/BSP/: myusart.c mycan.c rgbtft.c ws2812.c encoder.c lightsensor.c led_bottun.c yzusart.c atk_mw8266d.c atk_mw8266d_uart.c
  group App
    ../App/: canapp.c wifiapp.c
  group LVGL\lvgl\examples\porting
    ../LVGL/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
  group LVGL\lvgl\src\core
    ../LVGL/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL\lvgl\src\draw
    ../LVGL/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../LVGL/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../LVGL/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../LVGL/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../LVGL/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../LVGL/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group LVGL\lvgl\src\extra
    ../LVGL/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../LVGL/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../LVGL/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../LVGL/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/lvgl/src/extra/others/msg/: lv_msg.c
    ../LVGL/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/lvgl/src/extra/widgets/led/: lv_led.c
    ../LVGL/lvgl/src/extra/widgets/list/: lv_list.c
    ../LVGL/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/lvgl/src/extra/widgets/span/: lv_span.c
    ../LVGL/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/lvgl/src/extra/widgets/win/: lv_win.c
    ../LVGL/lvgl/src/extra/: lv_extra.c
  group LVGL\lvgl\src\font
    ../LVGL/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL\lvgl\src\hal
    ../LVGL/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL\lvgl\src\misc
    ../LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL\lvgl\src\widgets
    ../LVGL/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group README
    ../: readme.md
  group LVGL\lvgl_app\lvgl_app_3
    ../LVGL/lvgl_app/lvgl_app_3/: _elitr_alpha_363x68.c custom.c custom.h events_init.c events_init.h gui_guider.c gui_guider.h guider_customer_fonts.h guider_fonts.h lv_font_Acme_Regular_20.c lv_font_Alatsi_Regular_14.c lv_font_Alatsi_Regular_18.c lv_font_Alatsi_Regular_20.c lv_font_Antonio_Regular_24.c lv_font_arial_45.c lv_font_CN_12.c lv_font_CN_80.c lv_font_montserratMedium_14.c lv_font_montserratMedium_15.c lv_font_montserratMedium_16.c lv_font_montserratMedium_18.c lv_font_montserratMedium_20.c lv_font_montserratMedium_25.c lv_font_montserratMedium_30.c lv_font_montserratMedium_35.c lv_font_montserratMedium_38.c lv_font_montserratMedium_40.c lv_font_montserratMedium_41.c lv_font_montserratMedium_45.c lv_font_montserratMedium_50.c lv_font_montserratMedium_51.c lv_font_montserratMedium_60.c lv_font_montserratMedium_110.c lv_font_simsun_18.c setup_scr_screen.c widgets_init.c widgets_init.h
software components: CMSIS:CORE 5.6.0
